# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --no_strict
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Middle_Drivers;..\ThirdParty\mavlink;..\ThirdParty\mavlink\common;..\Middle_Drivers;../Middlewares/Third_Party/FatFs/src;..\Modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: sdlog.c main.c gpio.c dma.c bsp_driver_sd.c sd_diskio.c fatfs.c sdio.c spi.c sys.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c example.c
  group Application/Middle_Driver
    ../Middle_Drivers/: md_struct.h md_include.h md_led_driver.c md_mpu6000.c md_ms56xx.c md_hmc5883.c md_gps.c md_ubx.c ringbuffer.c md_twoboardcom.c
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Application/Mavlink
    ../ThirdParty/mavlink/common/: common.h mavlink.h testsuite.h mavlink_msg_gps_raw_int.h mavlink_msg_raw_imu.h mavlink_msg_heartbeat.h
    ../ThirdParty/mavlink/: mavlink_helpers.h mavlink_get_info.h mavlink_conversions.h mavlink.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Modules
    ../Modules/: Filter.c sensor.c User_Library.c mode.c
software components: CMSIS:CORE 4.1.0
